# Keil uVision project STM32-LED.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-LED
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\Bsp;..\FWlib\inc;..\FWlib\src;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group App
    ../App/: main.c UserApp.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_dma.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Bsp
    ../Bsp/: stm32f10x_it.c SysTick.c Infrared_Send.c Infrared_Recv.c Boost_pwm.c Usart1.c Adc.c Control_GPIO.c Charge_pwm.c EEpromInFlash.c Pvd.c
software components: CMSIS:CORE 4.3.0
